# Keil uVision project my_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\CALCULATE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\DISPLAY\LCD;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\DISPLAY\LCD12864;..\HARDWARE\EXTI;..\UI;..\HARDWARE\BKP;..\HARDWARE\RTC;..\HARDWARE\DS18B20;..\HARDWARE\EEPROM;..\HARDWARE\RS232;..\PGCP;..\COMMUNICATION;..\HARDWARE\TIMER;..\HARDWARE\WDG;..\HARDWARE\DSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group DARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DISPLAY/LCD/: lcd.c
    ../HARDWARE/DISPLAY/LCD12864/: lcd12864.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/BKP/: bkp.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/EEPROM/: eeprom.c myiic.c
    ../HARDWARE/RS232/: rs232.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/DSP/: dsp.c
  group CALCULATE
    ../CALCULATE/: calculate.c fft.c
  group UI
    ../UI/: user_interface.c
  group PGCP
    ../PGCP/: pgcp.c
  group COMMUNICATION
    ../COMMUNICATION/: communication.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
